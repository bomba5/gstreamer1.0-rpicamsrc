require gstreamer1.0-rpicamsrc.inc

SRC_URI[md5sum] = "52c7e826aa2891f0605e9a6f6d4cd6bf"
SRC_URI[sha256sum] = "53a4aedca9545961e3b177df70a2fe70b5d4960084ecdf18f662a90898d464c6"

LIC_FILES_CHKSUM = "file://COPYING;md5=602b8b30f980405460454f8bd5d447d2"
